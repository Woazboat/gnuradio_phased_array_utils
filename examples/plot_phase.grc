options:
  parameters:
    author: florian
    generate_options: qt_gui
    id: plot_phase
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: azimuth
  id: variable_qtgui_range
  parameters:
    label: Azimuth
    start: '0'
    step: '1'
    stop: '360'
    value: '54'
  states: {}
- name: elevation
  id: variable_qtgui_range
  parameters:
    label: Elevation
    start: '0'
    step: '1'
    stop: '90'
    value: '45'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: 'pmt.cons(pmt.to_pmt({"az": azimuth, "el": elevation}),pmt.to_pmt(None))'
    period: '1000'
  states: {}
- name: blocks_throttle_0_0_4_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0_4_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0_4_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0_4_0_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0_4_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0_4_0_1_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0_4_0_1_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0_4_0_2
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0_4_0_3
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: phased_array_2d_calcPhase_0
  id: phased_array_2d_calcPhase
  parameters:
    azimuth: azimuth
    elevation: elevation
    f: '500000000'
    num_antennas: '9'
    p_antennas: '[(0.0, 0.0), (0.299792458, 0.0), (0.599584916, 0.0), (0.0, 0.299792458), (0.299792458, 0.299792458), (0.599584916, 0.299792458), (0.0, 0.599584916), (0.299792458, 0.599584916), (0.599584916, 0.599584916)]'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: Phase Offset
    nconnections: '9'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '7'
    ymin: '-7'
  states: {}
- name: variable_qtgui_azelplot_0
  id: variable_qtgui_azelplot
  parameters: {}
  states: {}

connections:
- [blocks_message_strobe_0, strobe, variable_qtgui_azelplot_0, azel]
- [blocks_throttle_0_0_4_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_throttle_0_0_4_0_0, '0', qtgui_time_sink_x_2, '1']
- [blocks_throttle_0_0_4_0_0_0, '0', qtgui_time_sink_x_2, '4']
- [blocks_throttle_0_0_4_0_0_1, '0', qtgui_time_sink_x_2, '7']
- [blocks_throttle_0_0_4_0_1, '0', qtgui_time_sink_x_2, '2']
- [blocks_throttle_0_0_4_0_1_0, '0', qtgui_time_sink_x_2, '5']
- [blocks_throttle_0_0_4_0_1_1, '0', qtgui_time_sink_x_2, '8']
- [blocks_throttle_0_0_4_0_2, '0', qtgui_time_sink_x_2, '3']
- [blocks_throttle_0_0_4_0_3, '0', qtgui_time_sink_x_2, '6']
- [phased_array_2d_calcPhase_0, '0', blocks_throttle_0_0_4_0, '0']
- [phased_array_2d_calcPhase_0, '1', blocks_throttle_0_0_4_0_0, '0']
- [phased_array_2d_calcPhase_0, '2', blocks_throttle_0_0_4_0_1, '0']
- [phased_array_2d_calcPhase_0, '3', blocks_throttle_0_0_4_0_2, '0']
- [phased_array_2d_calcPhase_0, '4', blocks_throttle_0_0_4_0_0_0, '0']
- [phased_array_2d_calcPhase_0, '5', blocks_throttle_0_0_4_0_1_0, '0']
- [phased_array_2d_calcPhase_0, '6', blocks_throttle_0_0_4_0_3, '0']
- [phased_array_2d_calcPhase_0, '7', blocks_throttle_0_0_4_0_0_1, '0']
- [phased_array_2d_calcPhase_0, '8', blocks_throttle_0_0_4_0_1_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
